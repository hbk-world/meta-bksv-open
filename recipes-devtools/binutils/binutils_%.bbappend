PROVIDES_append = " virtual/mfgtool-${TARGET_PREFIX}binutils "
#PROVIDES_append = " virtual/mfgtool-${TARGET_PREFIX}binutils-native "
