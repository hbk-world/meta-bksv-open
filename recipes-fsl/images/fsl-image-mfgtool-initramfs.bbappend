
IMAGE_INSTALL += "fwup"
