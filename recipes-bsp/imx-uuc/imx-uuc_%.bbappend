FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Fix-mfgtool-comms-with-yocto-thud.patch"

