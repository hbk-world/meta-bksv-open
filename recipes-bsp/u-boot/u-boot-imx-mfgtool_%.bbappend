FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

inherit externalsrc
EXTERNALSRC = "${BSPDIR}/sources/u-boot-fslc"

