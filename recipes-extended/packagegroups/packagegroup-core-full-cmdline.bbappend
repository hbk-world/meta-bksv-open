
RDEPENDS_packagegroup-core-full-cmdline-sys-services = "\
    at \
    bzip2 \
    cronie \
    dbus \
    elfutils \
    gzip \
    less \
    logrotate \
    pciutils \
    rpcbind \
    tcp-wrappers \
    tzdata \
    "
