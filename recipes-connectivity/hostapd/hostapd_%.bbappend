FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-Configure-hostapd.patch \
            file://0001-Enable-automatic-channel-selection.patch \
            "

