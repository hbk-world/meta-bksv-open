FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Suppress-CTRL-EVENT-SCAN-FAILED-message.patch"

