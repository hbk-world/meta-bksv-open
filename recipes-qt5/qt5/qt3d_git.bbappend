PACKAGECONFIG[assimp] = ",,assimp"
